<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\Lab7Empty\adc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\Documents\GitHub\Labs\lab2\checks.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\iarproject.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\Lab4EmptyTimer\lab4.ewp</path>
    </project>
    <batchBuild />
</workspace>
